# Repository CodonNine/4-axis-aircraft

File README.md:

<!--
 * @Description: 
 * @Version: 2.0
 * @Author: YU-XIAO
 * @Date: 2023-10-22 21:01:59
 * @LastEditors: YU-XIAO
 * @LastEditTime: 2023-10-22 21:03:08
-->
# 四轴飞行器
主控GD32F103TBU6，电池1S

## KiCad design 飞控/飞控.kicad_pcb

Parts:
C1, C2, C4, C6, C7, C8, C9, C10, C11, C13, C14, C15, C16, C17, C18, C21, C22, C23: 0.1u; C_0603_1608Metric
C3, C5: 22u; C_0603_1608Metric
C12: 4.7u; C_0603_1608Metric
C19, C20: 22p; C_0603_1608Metric
CN1: ZH1.5-2P-WT; CONN-SMD_ZH1.5-2P-WT
D1, D3, D4: LED; LED_0603_1608Metric
D2, D5, D6, D7, D8: 1N5819; D_SOD-123
H1, H2, H3, H4: MountingHole_Pad; hole_2x3mm
J1, J2, J3, J8, J9, J10: Conn_01x01_Pin; TestPoint_Pad_D1.0mm
J4, J5, J6, J7, J11, J12, J13, J14: Conn_01x01_Pin; SolderWirePad_1x01_SMD_1x2mm
L1: 4.7u; IND-SMD_L4.9-W4.4_MAPM0420F
Q1, Q2, Q3, Q4: AO3400A; SOT-23
R1, R2, R4, R5, R7, R10, R11, R12, R13, R14, R15: 10k; R_0603_1608Metric
R3: 150k; R_0603_1608Metric
R6: 20.5k; R_0603_1608Metric
R8, R9: 1k; R_0603_1608Metric
SW1: RST; SW-SMD_L4.0-W2.9-LS4.8-1
SW2: MST22D18G2_125; SW-SMD_MST22D18G2
U1: SX1308; SOT-23-6
U2: 2.4G-UART
U3: BMP280; Bosch_LGA-8_2x2.5mm_P0.65mm_ClockwisePinNumbering
U4: ME6206A33M3G; SOT-23
U6: W25Q32JVSS; SOIC-8_5.23x5.23mm_P1.27mm
U7: MPU-6050; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
U8: GD32F103TBU6; QFN-36-1EP_6x6mm_P0.5mm_EP3.7x3.7mm
U9: ZX-ZH1.5-3PWT; CONN-SMD_3P-P1.50_ZX-ZH1.5-3PWT
Y1: 8M; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C1.1, C2.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, J1.1, R1.1, R4.1, R7.1, R8.1, R9.1, R13.2, U2.2 (VCC), U3.6 (VDDIO), U3.8 (VDD), U4.2 (OUT), U6.3 (IO2), U6.7 (IO3), U6.8 (VCC), U7.8 (VLOGIC), U7.13 (VDD), U8.1 (VDD_3), U8.6 (VDDA), U8.19 (VDD_1), U8.27 (VDD_2)
+5V: C3.1, C4.1, C7.1, C8.1, D2.1 (K), R3.1, U4.3 (VIN), U9.1
+BATT: C5.1, C6.1, D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), J4.1, J5.1, J6.1, J12.1, L1.2, R2.1, SW2.1, SW2.4, U1.4 (EN), U1.5 (IN)
/6050_INT: U7.12 (INT), U8.30 (PB3)
/6050_SCL: R8.2, U7.23 (SCL), U8.34 (PB7)
/6050_SDA: R9.2, U7.24 (SDA), U8.33 (PB6)
/BAT_ADC: R2.2, R5.1, U8.7 (PA0-WKUP)
/BMP280_CS: U3.2 (CSB), U8.17 (PB2)
/FB: R3.2, R6.1, U1.3 (FB)
/LED1: D1.1 (K), U8.24 (PA12)
/LED2: D3.1 (K), U8.23 (PA11)
/M1: D5.2 (A), J11.1, Q1.3 (D)
/M2: D6.2 (A), J13.1, Q2.3 (D)
/M3: D7.2 (A), J14.1, Q3.3 (D)
/M4: D8.2 (A), J7.1, Q4.3 (D)
/NRST: C23.1, R13.1, SW1.1, U8.4 (NRST)
/OSC_IN: C19.2, U8.2 (OSC_IN/PD0), Y1.3
/OSC_OUT: C20.2, U8.3 (OSC_OUT/PD1), Y1.1
/PWM1: Q2.1 (G), R11.1, U8.31 (PB4)
/PWM2: Q1.1 (G), R10.1, U8.32 (PB5)
/PWM3: Q3.1 (G), R14.1, U8.16 (PB1)
/PWM4: Q4.1 (G), R15.1, U8.15 (PB0)
/SPI_CS: U6.1 (~CS), U8.11 (PA4)
/SPI_MISO: U3.5 (SDO), U6.2 (DO(IO1)), U8.13 (PA6)
/SPI_MOSI: U3.3 (SDI), U6.5 (DI(IO0)), U8.14 (PA7)
/SPI_SCK: U3.4 (SCK), U6.6 (CLK), U8.12 (PA5)
/SW: D2.2 (A), L1.1, U1.1 (SW)
/SWCLK: J2.1, U8.28 (PA14)
/SWDIO: J3.1, U8.25 (PA13)
/U1_RX: J8.1, U8.22 (PA10), U9.2
/U1_TX: J9.1, U8.21 (PA9)
/U2_RX: U2.5 (TX), U8.10 (PA3)
/U2_TX: U2.4 (RX), U8.9 (PA2)
/UART_RST: U2.1 (RST), U8.8 (PA1)
/VIN: CN1.1, SW2.2, SW2.5
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.1, C20.1, C21.1, C22.1, C23.2, CN1.2, D4.1 (K), H1.1, H2.1, H3.1, H4.1, J10.1, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R5.2, R6.2, R10.2, R11.2, R12.2, R14.2, R15.2, SW1.2, U1.2 (GND), U2.3 (GND), U2.7 (GND), U3.1 (GND), U3.7 (GND), U4.1 (GND), U6.4 (GND), U7.1 (CLKIN), U7.9 (AD0), U7.11 (FSYNC), U7.18 (GND), U8.5 (VSSA), U8.18 (VSS_1), U8.26 (VSS_2), U8.36 (VSS_3), U8.37 (EP), U9.3, Y1.2, Y1.4
unnamed: D1.2 (A), R1.2
unnamed: D3.2 (A), R4.2
unnamed: D4.2 (A), R7.2
unnamed: C22.2, U7.20 (CPOUT)
unnamed: C21.2, U7.10 (REGOUT)
unnamed: R12.1, U8.35 (BOOT0)

Notes on the sheet:
气压计
电机输出
无线通信
指示灯
摄像头
MPU-6050
调试接口
电源输入
电压监测
电源管理
8M FLASH
最小系统

Board: 4 copper layers, 52.0 x 25.0 mm, 80 parts (2 on the bottom side), 42 nets.

## KiCad design 遥控器/遥控器.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C8, C11, C12, C14, C15, C19, C20, C21, C22: 0.1u; C_0603_1608Metric
C7, C9: 22u; C_0603_1608Metric
C10, C13, C16: 10u; C_0603_1608Metric
C17, C18: 22p; C_0603_1608Metric
D1: D; D_SOD-123
J1, J2, J3, J4, J5, J6: Conn_01x01_Pin; SolderWirePad_1x01_SMD_1x2mm
J7: USB_C_Receptacle_USB2.0; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
L1: L; L_Chilisin_BMRA00040420
L2: 10R 100M; L_0603_1608Metric
R1, R4: 150k; R_0603_1608Metric
R2: 1k; R_0603_1608Metric
R3, R7: 20.5k; R_0603_1608Metric
R5, R6, R8: 10k; R_0603_1608Metric
R9, R10: 4.7k; R_0603_1608Metric
SW1: SK12F14G5; SW-TH_SK12F14G5
SW2: SW_Push; SW-SMD_L4.0-W2.9-LS4.8-1
SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12: SW_Push; SW_Push_1P1T_NO_6x6mm_H9.5mm
SW13, SW14: SW_Push; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS
U1: SX1308; SOT-23-6
U2: IPS_1.14_135X240_ST7789_13P顶层; 1.14IPS-LCD
U3: STM32F103RCTx; LQFP-64_10x10mm_P0.5mm
U4: ME6206A33M3G; SOT-23
U5: 2.4G-UART
U6: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U7: SOP-8_3.9x4.9mm_P1.27mm
U8: 10k; 16x16 360度回中
U9: 10k; 摇杆16x16一字不回中
Y1: 8M; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, C5.1, C15.1, C16.1, C19.1, C20.2, J5.1, L2.1, R2.1, R5.1, U2.10 (VCC), U2.12 (LEDA), U3.1 (VBAT), U3.19 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD), U4.2 (OUT), U5.2 (VCC), U6.3 (IO2), U6.7 (IO3), U6.8 (VCC), U8.3 (10k), U8.6 (10k), U9.3 (10k)
+3.3VA: C10.1, C11.1, L2.2, U3.13 (VDDA)
+5V: C8.1, C9.1, C13.1, C14.1, C22.1, D1.1 (K), J7.A4 (VBUS), J7.A9 (VBUS), J7.B4 (VBUS), J7.B9 (VBUS), R1.1, U4.3 (VIN), U7.5 (VCC)
+BATT: C6.1, C7.1, L1.2, R4.1, SW1.2, U1.4 (EN), U1.5 (IN)
+VDC: J1.1, SW1.1; also elsewhere on the board
/2.4G_RST: U3.14 (PA0), U5.1 (RST)
/AD1: U3.9 (PC1), U8.2 (R)
/AD2: U3.10 (PC2), U8.5 (R)
/AD3: U3.11 (PC3), U9.2 (R)
/AD_BATT: R4.2, R7.1, U3.8 (PC0)
/BOOT0: R6.1, U3.60 (BOOT0)
/BOOT1: R8.1, U3.28 (PB2)
/CE: U3.15 (PA1), U5.6 (CE)
/CS1: U2.7 (CS), U3.26 (PB0)
/CS2: U3.33 (PB12), U6.1 (~CS)
/D+: J7.A6 (D+), J7.B6 (D+), U7.1 (D+)
/D-: J7.A7 (D-), J7.B7 (D-), U7.2 (D-)
/FB: R1.2, R3.1, U1.3 (FB)
/OSC_IN: C17.2, U3.5 (PD0), Y1.3
/OSC_OUT: C18.2, U3.6 (PD1), Y1.1
/RES: U2.6 (RES), U3.25 (PC5)
/RS: U2.5 (RS), U3.24 (PC4)
/RST: C12.1, R5.2, SW2.1, U3.7 (NRST); also elsewhere on the board
/S1: SW3.1, U3.45 (PA12)
/S2: SW4.1, U3.50 (PA15)
/S3: SW5.1, U3.52 (PC11)
/S4: SW6.1, U3.51 (PC10)
/S5: SW7.1, U3.58 (PB6)
/S6: SW8.1, U3.56 (PB4)
/S7: SW9.1, U3.55 (PB3)
/S8: SW10.1, U3.57 (PB5)
/S9: SW11.1, U3.59 (PB7)
/S10: SW12.1, U3.54 (PD2)
/S11: SW13.1, U3.30 (PB11)
/S12: SW14.1, U3.29 (PB10)
/SPI1_SCL: R2.2, U2.4 (SCL), U3.21 (PA5)
/SPI1_SDA: U2.3 (SDA), U3.23 (PA7)
/SPI2_MISO: U3.35 (PB14), U6.2 (DO(IO1))
/SPI2_MOSI: U3.36 (PB15), U6.5 (DI(IO0))
/SPI2_SCL: U3.34 (PB13), U6.6 (CLK)
/SW: D1.2 (A), L1.1, U1.1 (SW)
/SWCLK: J4.1, U3.49 (PA14)
/SWDIO: J3.1, U3.46 (PA13)
/USART1_RX: U3.43 (PA10), U7.6 (TXD)
/USART1_TX: U3.42 (PA9), U7.7 (RXD)
/USART2_RX: U3.17 (PA3), U5.5 (TX)
/USART2_TX: U3.16 (PA2), U5.4 (RX)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.1, C19.2, C20.1, C21.1, C22.2, J2.1, J6.1, J7.A1 (GND), J7.A12 (GND), J7.B1 (GND), J7.B12 (GND), J7.S1 (SHIELD), R3.2, R6.2, R7.2, R8.2, R9.2, R10.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, SW14.2, U1.2 (GND), U2.8 (GND), U2.11 (LEDK), U2.13 (GND), U3.12 (VSSA), U3.18 (VSS), U3.31 (VSS), U3.47 (VSS), U3.63 (VSS), U4.1 (GND), U5.3 (GND), U5.7 (GND), U6.4 (GND), U7.3 (GND), U8.1 (0), U8.4 (0), U9.1 (0), Y1.2, Y1.4; also elsewhere on the board
unnamed: J7.A5 (CC1), R9.1
unnamed: J7.B5 (CC2), R10.1
unnamed: C21.2, U7.8 (V3)

Board: 2 copper layers, 150.0 x 90.8 mm, 66 parts (5 on the bottom side), 51 nets.

Other parts of the board:
BAT+: Conn_01x01_Pin; SolderWirePad_1x01_SMD_1x2mm
BAT-: Conn_01x01_Pin; SolderWirePad_1x01_SMD_1x2mm
RESET: SW_Push; SW-SMD_L4.0-W2.9-LS4.8-1

Their connections:
+VDC: BAT+.1; also elsewhere on the board
/RST: RESET.1; also elsewhere on the board
GND: BAT-.1, RESET.2; also elsewhere on the board

## Commit log

2023-10-16 第一次提交
2023-10-16 原理图批注
2023-10-16 批注原理图
2023-10-22 完成原理图，pcb布局
2023-10-22 add readme
2023-10-26 完成pcb绘制
2024-01-05 飞控原理图完成
2024-01-19 飞控pcb布局
2024-02-24 飞控修改
